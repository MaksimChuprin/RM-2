# IAR project rm-2.ewp, settings and files
configuration RM-2L v3.xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F10X_CL; STM32F107xC; USE_PP; __RM_2_02_USER_CDC; __WEO012864G; __WEG012864M_old; __ETH_REMAP__; __ARM__; __V3XX__
  ICCARM.CCIncludePath2: fitted cyclone; Setup; Application; CustomHID; CustomHID\CDC\Inc; CustomHID\Core\Inc; $TOOLKIT_DIR$\INC\ST\; Y:\Programs\Service\Modbus\; Y:\Programs\Service\EKSIS\; Y:\Programs\Service\ARM\common; Y:\Programs\Service\ARM\St\; Y:\Programs\Service\ARM\St\ST_HID\; Y:\Programs\Service\ARM\St\ST_TCP\; Y:\Programs\Service\ARM\STM32F1xx_HAL_Driver\Inc\; Y:\Programs\Service\ARM\stm32f10x_std_periph_lib\inc; Y:\Programs\Service\ARM\cmsis\include\; Y:\Programs\Service\ARM\cmsis\Device\ST\STM32F1xx\Include\; Y:\Programs\Service\ARM\Middlewares\ST\STM32_USB_Device_Library\Core\Inc\; Y:\Programs\Service\ARM\cyclone_tcp\; Y:\Programs\Service\SX1276\; Y:\Programs\Service\PowerPac\RTOS\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RM-2 LoRa v316.hex
  ILINK.IlinkOutputFile: rm-2.out
  ILINK.IlinkIcfFile: Setup\FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    Application/: eksis_bin_ip.c gsm.c OLED.c OS_IP_task.c OS_MQTT_task.c OS_Start.c RTOSInit.c UARTs_task.c USB_Task.c utilites.c web_server.c WIFI_task.c
  group common/headers
    Application/: defines.h device_struct.h F868_task.h global_var.h gsm.h OLED.h OS_IP_task.h OS_MQTT_task.h UARTs_task.h USB_Task.h utilites.h WIFI_task.h
    ../../Service/EKSIS/: eksis.h
  group Ethernet/common
    ../../Service/ARM/common/: cpu_endian.c date_time.c str.c
  group Ethernet/Fitted Cyclone TCP
    ../../Service/ARM/St/ST_TCP/: dp83848.c IP_init.c net.c pp_rtos.c stm32f107_eth.c
    ../../Service/ARM/St/ST_MQTTGSM/: mqtt_client_transport.c
    Setup/: net_config.h
  group Ethernet/Original CycloneTCP Sources
    ../../Service/ARM/cyclone_tcp/ipv4/: arp.c icmp.c igmp.c ipv4.c ipv4_frag.c
    ../../Service/ARM/cyclone_tcp/core/: bsd_socket.c ethernet.c ip.c net_mem.c nic.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../../Service/ARM/cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../Service/ARM/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../Service/ARM/cyclone_tcp/mqtt/: mqtt_client.c mqtt_client_misc.c mqtt_client_packet.c
    ../../Service/ARM/cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
    ../../Service/ARM/cyclone_tcp/sntp/: sntp_client.c
  group Fonts
    Fonts/: CourierNew16.c CourierNew8.c logo.c Tahoma12.c Tahoma16.c
  group lib
    $EW_DIR$/arm/PowerPac/RTOS/Lib/: os7m_tl__r.a
  group modbus
    Application/: modbus_param.h
  group modbus/mod_lib
    ../../Service/Modbus/: modbus.c
  group setup
    Setup/: FLASH.icf OS_Error.c RTOSVect.c
  group STM32F10x HAL Driver
    ../../Service/ARM/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rcc.c stm32f1xx_ll_usb.c
  group SX1276
    ../../Service/SX1276/: sx1276.c
  group SX1276/headers
    ../../Service/SX1276/: sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
  group USB/CDC
    CustomHID/CDC/Src/: usbd_cdc.c usbd_cdc_if_template.c
  group USB/Current
    ../../Service/ARM/St/ST_HID/: stm32f1xx_hal_msp.c
    CustomHID/: usbd_conf.c usbd_customhid.c usbd_customhid_if.c usbd_desc.c
  group USB/STM32_USBD_Library
    ../../Service/ARM/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group V3.xx
    Application/: F868_task_v3xx.c global_var_v3xx.c
